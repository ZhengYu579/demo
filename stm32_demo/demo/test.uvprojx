# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC11C14FBD48/301 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(50000000) ELITTLE
  output: test
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\demo;.\key_demo;.\led_demo;.\nled_demo;.\speaker_demo;.\timer_demo;.\wdt_demo;.\music_demo;.\uart_demo;.\ADC_demo;.\DHT11_demo
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Source Group 1
    ./: test.c my.h
    ./key_demo/: key.c key.h
    ./led_demo/: led.h led.c
    ./nled_demo/: nled.c nled.h
    ./speaker_demo/: speaker.h speaker.c
    ./timer_demo/: timer.c timer.h
    ./wdt_demo/: wdt.c wdt.h
    ./music_demo/: music.h music.c
    ./uart_demo/: uart.h uart.c
    ./ADC_demo/: ad.h ad.c
    ./DHT11_demo/: dht.c dht.h
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
